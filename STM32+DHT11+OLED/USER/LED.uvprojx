# Keil uVision project LED.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LED;..\SYSTEM\Serial;..\HARDWARE\PWM;..\HARDWARE\OLED;..\HARDWARE\DHT11;..\HARDWARE\USart;..\HARDWARE\KEY;..\HARDWARE\PM25;..\SYSTEM\adc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/USart/: Serial.c
    ../HARDWARE/PM25/: PM25.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/adc/: adcx.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c
  group README
    ../: README.TXT
